# Keil uVision project SOC_LVGL.uvprojx, settings and files
target Target (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: SOC_LVGL +hex
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: LV_CONF_INCLUDE_SIMPLE
  c misc: --gnu --diag_suppress=61 --diag_suppress=68 --diag_suppress=111 --diag_suppress=177 --diag_suppress=186 --diag_suppress=188 --diag_suppress=191 --diag_suppress=546 --diag_suppress=1293
  c include: .\Headers;.\Drivers\includes;.\System\includes;.\Middlewares;.\Middlewares\LVGL;.\Middlewares\LVGL\src;.\Middlewares\LVGL\examples\porting;.\GUI
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ./Startup/: startup_sc32f11xxb.s
  group Drivers
    ./Drivers/sources/: sc32f10xx_gpio.c sc32f10xx_rcc.c sc32f10xx_touch_key_parameter_analysis.c sc32r803_tim.c sc32r803_uart.c sc32f10xx_high_sensitive_lib_t1_v0.3.lib sc32f10xx_touch_key_dynamic_debug_v0.3.lib
  group System
    ./System/sources/: data.c delay.c dma.c gpio.c lcd.c main.c qspi.c timer.c uart.c w25q16.c
  group Middlewares/LVGL/src
    ./Middlewares/LVGL/src/: lv_init.c
  group Middlewares/LVGL/src/core
    ./Middlewares/LVGL/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_property.c
  group Middlewares/LVGL/src/display
    ./Middlewares/LVGL/src/display/: lv_display.c
  group Middlewares/LVGL/src/draw
    ./Middlewares/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c
    ./Middlewares/LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ./Middlewares/LVGL/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb888.c
  group Middlewares/LVGL/src/font
    ./Middlewares/LVGL/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_14_cjk.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group Middlewares/LVGL/src/indev
    ./Middlewares/LVGL/src/indev/: lv_indev.c lv_indev_scroll.c
  group Middlewares/LVGL/src/layouts
    ./Middlewares/LVGL/src/layouts/flex/: lv_flex.c
    ./Middlewares/LVGL/src/layouts/grid/: lv_grid.c
    ./Middlewares/LVGL/src/layouts/: lv_layout.c
  group Middlewares/LVGL/src/libs
    ./Middlewares/LVGL/src/libs/barcode/: code128.c lv_barcode.c
    ./Middlewares/LVGL/src/libs/bin_decoder/: lv_bin_decoder.c
    ./Middlewares/LVGL/src/libs/bmp/: lv_bmp.c
    ./Middlewares/LVGL/src/libs/ffmpeg/: lv_ffmpeg.c
    ./Middlewares/LVGL/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ./Middlewares/LVGL/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ./Middlewares/LVGL/src/libs/gif/: gifdec.c lv_gif.c
    ./Middlewares/LVGL/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ./Middlewares/LVGL/src/libs/libpng/: lv_libpng.c
    ./Middlewares/LVGL/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ./Middlewares/LVGL/src/libs/lz4/: lz4.c
    ./Middlewares/LVGL/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ./Middlewares/LVGL/src/libs/rle/: lv_rle.c
    ./Middlewares/LVGL/src/libs/rlottie/: lv_rlottie.c
    ./Middlewares/LVGL/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ./Middlewares/LVGL/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
  group Middlewares/LVGL/src/misc
    ./Middlewares/LVGL/src/misc/cache/: lv_cache.c lv_cache_entry.c lv_cache_lru_rb.c lv_image_cache.c lv_image_header_cache.c
    ./Middlewares/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_utils.c
  group Middlewares/LVGL/src/osal
    ./Middlewares/LVGL/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_windows.c
  group Middlewares/LVGL/src/others
    ./Middlewares/LVGL/src/others/file_explorer/: lv_file_explorer.c
    ./Middlewares/LVGL/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ./Middlewares/LVGL/src/others/gridnav/: lv_gridnav.c
    ./Middlewares/LVGL/src/others/ime/: lv_ime_pinyin.c
    ./Middlewares/LVGL/src/others/imgfont/: lv_imgfont.c
    ./Middlewares/LVGL/src/others/monkey/: lv_monkey.c
    ./Middlewares/LVGL/src/others/observer/: lv_observer.c
    ./Middlewares/LVGL/src/others/snapshot/: lv_snapshot.c
    ./Middlewares/LVGL/src/others/sysmon/: lv_sysmon.c
    ./Middlewares/LVGL/src/others/vg_lite_tvg/: vg_lite_matrix.c
  group Middlewares/LVGL/src/stdlib
    ./Middlewares/LVGL/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ./Middlewares/LVGL/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ./Middlewares/LVGL/src/stdlib/micropython/: lv_mem_core_micropython.c
    ./Middlewares/LVGL/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ./Middlewares/LVGL/src/stdlib/: lv_mem.c
  group Middlewares/LVGL/src/themes
    ./Middlewares/LVGL/src/themes/mono/: lv_theme_mono.c
    ./Middlewares/LVGL/src/themes/simple/: lv_theme_simple.c
    ./Middlewares/LVGL/src/themes/: lv_theme.c
    ./Middlewares/LVGL/src/themes/default/: lv_theme_default.c
  group Middlewares/LVGL/src/tick
    ./Middlewares/LVGL/src/tick/: lv_tick.c
  group Middlewares/LVGL/src/widgets
    ./Middlewares/LVGL/src/widgets/animimage/: lv_animimage.c
    ./Middlewares/LVGL/src/widgets/arc/: lv_arc.c
    ./Middlewares/LVGL/src/widgets/bar/: lv_bar.c
    ./Middlewares/LVGL/src/widgets/button/: lv_button.c
    ./Middlewares/LVGL/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ./Middlewares/LVGL/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ./Middlewares/LVGL/src/widgets/canvas/: lv_canvas.c
    ./Middlewares/LVGL/src/widgets/chart/: lv_chart.c
    ./Middlewares/LVGL/src/widgets/dropdown/: lv_dropdown.c
    ./Middlewares/LVGL/src/widgets/image/: lv_image.c
    ./Middlewares/LVGL/src/widgets/imagebutton/: lv_imagebutton.c
    ./Middlewares/LVGL/src/widgets/keyboard/: lv_keyboard.c
    ./Middlewares/LVGL/src/widgets/label/: lv_label.c
    ./Middlewares/LVGL/src/widgets/led/: lv_led.c
    ./Middlewares/LVGL/src/widgets/line/: lv_line.c
    ./Middlewares/LVGL/src/widgets/list/: lv_list.c
    ./Middlewares/LVGL/src/widgets/lottie/: lv_lottie.c
    ./Middlewares/LVGL/src/widgets/menu/: lv_menu.c
    ./Middlewares/LVGL/src/widgets/msgbox/: lv_msgbox.c
    ./Middlewares/LVGL/src/widgets/objx_templ/: lv_objx_templ.c
    ./Middlewares/LVGL/src/widgets/property/: lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_style_properties.c lv_textarea_properties.c
    ./Middlewares/LVGL/src/widgets/roller/: lv_roller.c
    ./Middlewares/LVGL/src/widgets/scale/: lv_scale.c
    ./Middlewares/LVGL/src/widgets/slider/: lv_slider.c
    ./Middlewares/LVGL/src/widgets/span/: lv_span.c
    ./Middlewares/LVGL/src/widgets/spinbox/: lv_spinbox.c
    ./Middlewares/LVGL/src/widgets/spinner/: lv_spinner.c
    ./Middlewares/LVGL/src/widgets/switch/: lv_switch.c
    ./Middlewares/LVGL/src/widgets/table/: lv_table.c
    ./Middlewares/LVGL/src/widgets/tabview/: lv_tabview.c
    ./Middlewares/LVGL/src/widgets/textarea/: lv_textarea.c
    ./Middlewares/LVGL/src/widgets/tileview/: lv_tileview.c
    ./Middlewares/LVGL/src/widgets/win/: lv_win.c
    ./Middlewares/LVGL/src/widgets/checkbox/: lv_checkbox.c
  group Middlewares/LVGL/examples/porting
    ./Middlewares/LVGL/examples/porting/: lv_port_fs_template.c lv_port_disp.c lv_port_indev.c
  group GUI
    ./GUI/: ui.c
    ./GUI/components/: ui_comp_hook.c
    ./GUI/screens/: ui_screen.c
